# Keil uVision project stm32f429.uvprojx, settings and files
target stm32f429 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F413VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00050000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DCProject +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F413_423xx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,USE_USB_OTG_FS
  c include: ..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\system;..\ucos;..\ucos\Port;..\ucos\source;..\user;..\bsp\ETH;..\bsp;..\fatfs;..\lwip-1.4.1\port;..\lwip-1.4.1\port\arch;..\lwip-1.4.1\src\include;..\lwip-1.4.1\src\include\ipv4;..\lwip-1.4.1\src\include\lwip;..\lwip-1.4.1\src\netif;..\app;..\lwip-1.4.1\port\UCOS305;..\Delay;..\app\can_test;..\bsp\USB\USB_APP;..\bsp\USB\STM32_USB_HOST_Library\Class\MSC\inc;..\bsp\USB\STM32_USB_HOST_Library\Core\inc;..\bsp\USB\STM32_USB_OTG_Driver\inc;..\app\usb_task;..\version;..\app\Display;..\app\Display\Dwin;..\app\Display\Key;..\app\Display\Menu;..\Pubilc;..\app\RS485Meter;..\app\GPS;..\MyList;..\app\GPRS;..\app\connect_ccu;..\app\Display\DispStatus;..\app\card_cpu;..\app\flash;..\app\RTC;..\app\fm;..\w5500\Internet;..\w5500\W5500;..\app\ETH;..\app\4G;..\app\connect_bms;..\app\control;..\app\ADSample;..\app\PCU\connectmodule;..\app\PCU\control;..\CJSON\cJSONFiles\cJSON
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group user
    ../user/: stm32f4xx_it.c main.c
    ../system/: SysConfig.c
    ../Pubilc/: DealWithChar.c
  group startup
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group cmsis
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group librarys
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group ucos_port
    ../ucos/Port/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group ucos_lib
    ../ucos/source/: ucos_ii.c
  group bsp
    ../bsp/: bsp_debug_usart.c bsp_sdio_sd.c bsp_uart.c bsp_rs485.c bsp_exti_irq.c bsp_spi.c bsp_i2c.c bsp_can.c bsp_adc.c bsp_rtc.c bsp_MPulse.c spi_flash.c bsp_io.c bsp_SST25VF016.c bsp_SST25VF016.h w25qxx.c w25qxx.h
    ../app/: UP.lib
  group fatfs-src
    ../fatfs/: diskio.c ff.c
    ../fatfs/option/: cc936.c
  group ucos_app
    ../ucos/APP/: app_hooks.c
  group delay
    ../Delay/: delay.c
  group usb_task
    ../app/usb_task/: usb_task.c
  group USB_OTG
    ../bsp/USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group USB_HOST
    ../bsp/USB/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ../bsp/USB/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_scsi.c
  group USB_APP
    ../bsp/USB/USB_APP/: usb_bsp.c usbh_usr.c
  group usb_main
    ../app/usb_main/: usb_main.c
  group version
    ../version/: version.c
  group display
    ../app/Display/Dwin/: DwinProtocol.c
    ../app/Display/Key/: Dispkey.c DispkeyFunction.c
    ../app/Display/Menu/: MenuDisp.c
    ../app/Display/: DisplayMain.c
    ../app/Display/DispStatus/: DispShowStatus.c
  group rtc
    ../app/RTC/: RTC_task.c
  group rs485_meter
    ../app/RS485Meter/: RS485Meter.c charging_Interface.c charging_Interface.h RS485Meter.h
  group card
    ../app/card_cpu/: card_cpu.c Des.c card_Interface.h waittimeout.c waittimeout.h
  group MyList
    ../MyList/: MyList.c
  group flash
    ../app/flash/: FlashDataDeal.c
  group W5500_USER
    ../w5500/Internet/: dhcp.c dhcp.h tcp_demo.c tcp_demo.h
    ../app/ETH/: W5500Main.c W5500Main.h
  group W5500
    ../w5500/W5500/: socket.c socket.h types.h utility.c utility.h w5500.c w5500.h w5500_conf.c w5500_conf.h
  group ConnectBMS
    ../app/connect_bms/: BmsTimeout.c ConnectBMS.c ConnectBMSFrame.c ConnectBMSInterface.c
  group Control
    ../app/control/: ControlMain.c controlmain.h
  group 4g
    ../app/4G/: 4GMain.c 4GRecv.c 4GSend.c _66Frame.c APFrame.c ZFFrame.c ModuleSIM7600.c HYFrame.c ZHFrame.c YKCFrame.c YKCFrame.h _66Frame.h
  group ADSample
    ../app/ADSample/: AdAdjust.c AdAdjust.h ADSamplemain.c ADSamplemain.h
  group ReadMe
    ./: ReadMe.txt
  group CJSON
    ../CJSON/cJSONFiles/cJSON/: cJSON.c test.c
software components: CMSIS:CORE 5.5.0
